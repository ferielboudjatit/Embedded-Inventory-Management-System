# Keil uVision project NFC08A1_PollingTagDetectNDEF.uvprojx, settings and files
target NFC08A1_PollingTagDetectNDEF (6180000::V6.18::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: NFC08A1_PollingTagDetectNDEF +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: ST25R3916B,USE_HAL_DRIVER,STM32L476xx
  c include: ../Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/Components/ST25R3916;../../../../../Drivers/BSP/NFC08A1;../../../../../Middlewares/ST/ndef/Inc;../../../../../Middlewares/ST/ndef/Inc/message;../../../../../Middlewares/ST/ndef/Inc/poller;../../../../../Middlewares/ST/rfal/Inc;../../../../../Middlewares/ST/rfal/Src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c nfc_conf.c analogConfigTbl_NFC08A1.c demo_ce.c ndef_demo.c ndef_dump.c logger.c app_x-cube-nfcx.c stm32l4xx_nucleo_bus.c stm32l4xx_nucleo.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ST25R3916/: rfal_rfst25r3916.c st25r3916.c st25r3916_aat.c st25r3916_com.c st25r3916_irq.c st25r3916_led.c timer.c
  group Drivers/BSP/NFC
    ../../../../../Drivers/BSP/NFC08A1/: nfc08a1.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/X-CUBE-NFC6/Wireless/MID_LIB/NDEF
    ../../../../../Middlewares/ST/ndef/Src/message/: ndef_message.c ndef_record.c ndef_type_aar.c ndef_type_bluetooth.c ndef_type_deviceinfo.c ndef_type_empty.c ndef_type_flat.c ndef_type_media.c ndef_type_text.c ndef_type_tnep.c ndef_type_uri.c ndef_type_vcard.c ndef_type_wifi.c ndef_type_wlc.c ndef_type_wpcwlc.c ndef_types.c
    ../../../../../Middlewares/ST/ndef/Src/poller/: ndef_poller.c ndef_poller_message.c ndef_poller_rf.c ndef_t2t.c ndef_t3t.c ndef_t4t.c ndef_t5t.c ndef_t5t_rf.c
  group Middlewares/X-CUBE-NFC6/Wireless/MID_LIB/RFAL/Default_Config
    ../../../../../Middlewares/ST/rfal/Src/: rfal_analogConfig.c rfal_crc.c rfal_cd.c rfal_dpo.c rfal_iso15693_2.c rfal_isoDep.c rfal_nfc.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_st25tb.c rfal_st25xv.c rfal_t1t.c rfal_t2t.c rfal_t4t.c
software components: CMSIS:CORE 5.6.0
